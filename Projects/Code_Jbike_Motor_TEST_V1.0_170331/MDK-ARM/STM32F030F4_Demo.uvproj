# Keil uVision project STM32F030F4_Demo.uvproj, settings and files
target STM32F030F4 (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0308_Discovery
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\..\STM32F030F4_LED_USART_TIM;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\MDK-ARM;..\..\..\BSP;..\..\..\Common;..\..\Code_Jbike_Motor_TEST_V1.0_170331
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./../: system_stm32f0xx.c
  group MDK-ARM
    ./../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group STM32F0xx_StdPeriph_Driver
    ./../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./../: main.c stm32f0xx_it.c
  group Common
    ../../../Common/: init.c
